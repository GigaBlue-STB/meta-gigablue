KV = "4.4.35"
SRCDATE = "20200226"

require gigablue-dvb-modules-hisi.inc

SRC_URI[md5sum] = "583b68e5e865aed2ffe96c72545fcea2"
SRC_URI[sha256sum] = "d7502229eb3a4cdeccde4b62be0fe4da9e880cb3ae5bec6a992396ce0d73f7d5"
