require gigablue-kodi.inc

COMPATIBLE_MACHINE = "^(gbquad4k)$"

PV = "1.0"

GLPR = "20180904-r0"

SRC_URI[md5sum] = "c9e208f1adf4da2afa2f924be9895f81"
SRC_URI[sha256sum] = "8496405b70c0ad61e1f3c36abcd126678bfe0c4ece2c1fb24e7e035c141e5d30"
